Properties of the parts of a building model (IFC4)

# File
Description: Montageflansch für Einbaukanalfühler EKF/IKF/GFL, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: G9990160, Montageflansch für Einbaukanalfühler EKF/IKF/GFL
In: Raum
Description: Montageflansch für Einbaukanalfühler EKF/IKF/GFL bei Einsatz in Luftkanälen.; Classification: EC011349 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: G9990160; ModelLabel: MF; GlobalTradeItemNumber: 4050528044099; ProductURL: https://alre.de/produkt_G9990160
Pset_Specification - NominalLength: 0.04 m; NominalWidth: 0.04 m; NominalDepth: 0.013 m; NetWeight: 0.015
Pset_ALRE_ETIM_Properties - ETIM-Klasse: EC011349; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-G9990160.pdf
